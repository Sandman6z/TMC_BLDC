# Keil uVision project STM32F107.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NIBP_U65HN-024KS-6 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\STM32F10x_StdPeriph_Driver\src;..\Project;..\User;..\CoreSupport;..\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc
  asm include: .\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;..\STM32F107;..\NIBP-PS-2.00调试+风扇正常\FWlib;..\NIBP-PS-2.00调试+风扇正常
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../startup/: startup_stm32f10x_cl.s
  group CMSIS
    ../STM32F10x/: system_stm32f10x.c
    ../CoreSupport/: core_cm3.c
  group USE
    ./: main.c stm32f10x_it.c
    ../User/: IIC_FMEEP.C TMC4671.c Uart.c uart_process.c
  group Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.5.0
