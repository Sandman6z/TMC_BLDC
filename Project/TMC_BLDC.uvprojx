# Keil uVision project TMC_BLDC.uvprojx, settings and files
target BLDC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TMC_BLDC +hex
  c flags: Optim=2 oTime=1 uC99=1 v6Lang=3 v6LangP=3
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\Libraries\CMSIS\CoreSupport;..\User;..\Core\Inc
  asm include: .\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;..\STM32F107;..\NIBP-PS-2.00调试+风扇正常\FWlib;..\NIBP-PS-2.00调试+风扇正常
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_md.s
  group Core
    ../Core/Src/: main.c stm32f10x_it.c
  group Drivers/BSP
    ../User/: bsp_adc.c bsp_gpio.c bsp_led.c bsp_TMC4671.c bsp_monitor.c bsp_TurboCtrl.c
  group Drivers/CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
  group Drivers/Std
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.6.0
